# Keil uVision project P1-LED_Control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: P1-LED_Control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c NVIC_program.c GPIO_program.c GPT_program.c STK_program.c LED_Control.c
  group include
    ./: NVIC_config.h NVIC_interface.h NVIC_private.h GPIO_private.h GPIO_interface.h GPT_private.h GPT_interface.h BIT_MATH.h STK_config.h STK_interface.h STK_private.h LED_Control.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
